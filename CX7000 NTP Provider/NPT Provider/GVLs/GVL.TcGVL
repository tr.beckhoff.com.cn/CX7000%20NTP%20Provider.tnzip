{attribute 'qualified_only'}
VAR_GLOBAL
	bCX7028_Out_1 AT %Q*: BOOL;
	bCX7028_Out_2 AT %Q*: BOOL;
	bCX7028_Out_3 AT %Q*: BOOL;
	bCX7028_Out_4 AT %Q*: BOOL;
END_VAR
